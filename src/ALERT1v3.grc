options:
  parameters:
    author: CD
    copyright: BoM
    description: 'Legacy ALERT '
    generate_options: qt_gui
    id: ALERT1v3
    output_language: python
    title: ALERT1v3
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 173.9e6
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabwid0@0:2,0,1,4
    start: 100e6
    step: 25e3
    stop: 200e6
    value: 173.9e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '250'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: rfGain
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabwid0@0:0,0,1,4
    start: '-100'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: rf_squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: tabwid0@0:1,0,1,4
    min_len: '1'
    start: '-50'
    step: '1'
    stop: '0'
    value: '-33'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: fsk_deviation_hz/2
  states: {}
- name: log_base_path
  id: variable
  parameters:
    value: '''/home/cdomotor/rf_log'''
  states: {}
- name: mqtt_broker_host
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: mqtt_broker_port
  id: variable
  parameters:
    value: '1883'
  states: {}
- name: mqtt_username
  id: variable
  parameters:
    value: ''''''
  states: {}
- name: mqtt_password
  id: variable
  parameters:
    value: ''''''
  states: {}
- name: mqtt_topic_prefix
  id: variable
  parameters:
    value: '''alert'''
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '0'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/decimation)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: rf_squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate_audio
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.04
    max_dev: '1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: demod_rate/300
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import json
      from gnuradio import gr
      import pmt
      import datetime
      import os
      import csv


      class blk(gr.basic_block):
          """
          ALERT decode logger.

          Accepts structured PMT messages on 'msg_in' and writes:
            - CSV summary rows
            - JSONL full events

          File layout:
            <base_path>/<YYYY-MM-DD>/
              rx_data_<HHMMSS>.csv
              rx_events_<HHMMSS>.jsonl
          """

          def __init__(self, base_path='/home/pi/rf_logs'):
              gr.basic_block.__init__(self, name='ALERT Event Logger', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self.base_path = base_path
              self.current_date = ''
              self.csv_file = None
              self.jsonl_file = None
              self.csv_writer = None

          def _open_session_files(self):
              now = datetime.datetime.now()
              date_str = now.strftime('%Y-%m-%d')
              session_str = now.strftime('%H%M%S')

              target_dir = os.path.join(self.base_path, date_str)
              os.makedirs(target_dir, exist_ok=True)

              csv_path = os.path.join(target_dir, f'rx_data_{session_str}.csv')
              jsonl_path = os.path.join(target_dir, f'rx_events_{session_str}.jsonl')

              self.csv_file = open(csv_path, 'a', newline='')
              self.jsonl_file = open(jsonl_path, 'a')
              self.csv_writer = csv.writer(self.csv_file)
              self.csv_writer.writerow([
                  'timestamp', 'status', 'sensor_id', 'format_id', 'is_binary', 'data_val', 'payload_hex', 'summary'
              ])
              self.current_date = date_str

          def _ensure_files(self):
              date_str = datetime.datetime.now().strftime('%Y-%m-%d')
              if self.csv_file is None or self.jsonl_file is None or date_str != self.current_date:
                  self._close_files()
                  self._open_session_files()

          def _close_files(self):
              if self.csv_file:
                  try:
                      self.csv_file.flush()
                      self.csv_file.close()
                  except Exception:
                      pass
              if self.jsonl_file:
                  try:
                      self.jsonl_file.flush()
                      self.jsonl_file.close()
                  except Exception:
                      pass
              self.csv_file = None
              self.jsonl_file = None
              self.csv_writer = None

          def _normalize_event(self, msg):
              now_ts = datetime.datetime.utcnow().isoformat() + 'Z'
              try:
                  event = pmt.to_python(msg)
              except Exception:
                  event = str(msg)

              if not isinstance(event, dict):
                  event = {
                      'schema': 'alert.decode.v1',
                      'ts': now_ts,
                      'status': 'raw',
                      'summary': str(event),
                      'display': str(event),
                      'decode': {},
                      'frame': {},
                  }

              event.setdefault('schema', 'alert.decode.v1')
              event.setdefault('ts', now_ts)
              event.setdefault('status', 'unknown')
              event.setdefault('decode', {})
              event.setdefault('frame', {})

              if not isinstance(event.get('decode'), dict):
                  event['decode'] = {}
              if not isinstance(event.get('frame'), dict):
                  event['frame'] = {}

              if 'summary' not in event:
                  event['summary'] = str(event.get('display', ''))
              if 'display' not in event:
                  event['display'] = str(event.get('summary', ''))

              return event

          def handle_msg(self, msg):
              try:
                  self._ensure_files()
                  event = self._normalize_event(msg)

                  decode = event.get('decode', {})
                  frame = event.get('frame', {})

                  row = [
                      event.get('ts', datetime.datetime.utcnow().isoformat() + 'Z'),
                      event.get('status', 'unknown'),
                      decode.get('sensor_id', ''),
                      decode.get('format_id', ''),
                      decode.get('is_binary', ''),
                      decode.get('data_val', ''),
                      frame.get('payload_hex', ''),
                      event.get('summary', ''),
                  ]

                  self.csv_writer.writerow(row)
                  self.csv_file.flush()

                  self.jsonl_file.write(json.dumps(event, default=str) + '\n')
                  self.jsonl_file.flush()

              except Exception as e:
                  self.logger.error(f'Logging error: {e}')

          def stop(self):
              self._close_files()
              return True
    base_path: log_base_path
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime


      class alert_protocol_decoder(gr.basic_block):
          """
          ALERT protocol decoder.

          Input:
            - float stream containing symbol decisions / soft-ish values

          Output stream (single float, kept for GRC compatibility):
            - decoded data_val as float

          Message outputs:
            - debug_out (PMT dict with structured decode payload)
            - stats_out (operator-friendly string counters)
          """

          FRAME_WORDS = 4
          PAYLOAD_BITS_PER_WORD = 8
          HUNT_TIMEOUT_SAMPLES = 3000  # ~10s at ~300 sym/s from current chain

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="ALERT Protocol Decoder",
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )

              self.message_port_register_out(pmt.intern("debug_out"))
              self.message_port_register_out(pmt.intern("stats_out"))

              self.state = "HUNTING_S"
              self.bit_buffer = []
              self.message_bits = []
              self.bits_per_word = 10
              self.word_count = 0

              self.frames_decoded = 0
              self.frames_dropped_output_full = 0
              self.frames_total = 0
              self.error_total = 0
              self._window_decode = 0
              self._window_errors = 0
              self._window_started = datetime.datetime.utcnow()

              self._samples_since_frame = 0
              self._hunt_timeout_raised = False

          def _publish_event(self, event_dict):
              try:
                  msg = pmt.to_pmt(event_dict)
              except Exception:
                  msg = pmt.intern(str(event_dict))
              self.message_port_pub(pmt.intern("debug_out"), msg)

          def _now_iso(self):
              return datetime.datetime.utcnow().isoformat() + "Z"

          def _publish_decode_error(self, error_code, message, details=None):
              event = {
                  "schema": "alert.decode.v1",
                  "ts": self._now_iso(),
                  "status": "error",
                  "quality": {
                      "score": 0.0,
                      "confidence": "low",
                  },
                  "errors": [{
                      "code": error_code,
                      "message": message,
                  }],
                  "frame": details or {},
                  "decode": {},
                  "summary": f"ERROR: {error_code}",
                  "display": f"ERROR: {error_code}",
              }
              self._publish_event(event)

          def _reset_word_collection(self):
              self.state = "HUNTING_S"
              self.bit_buffer = []

          def _reset_frame_collection(self):
              self.word_count = 0
              self.message_bits = []
              self._reset_word_collection()

          def _publish_stats_if_due(self, force=False):
              now = datetime.datetime.utcnow()
              elapsed = (now - self._window_started).total_seconds()
              if not force and elapsed < 1.0:
                  return

              decode_rate = (self._window_decode / elapsed) if elapsed > 0 else 0.0
              stats = {
                  "schema": "alert.operator.stats.v1",
                  "ts": now.isoformat() + "Z",
                  "decode_rate_hz": round(float(decode_rate), 3),
                  "total_decodes": int(self.frames_total),
                  "recent_errors": int(self._window_errors),
                  "error_total": int(self.error_total),
                  "window_seconds": round(float(elapsed), 3),
                  "display": f"rate={decode_rate:.2f}/s | total={self.frames_total} | recent_errors={self._window_errors}",
              }
              self.message_port_pub(pmt.intern("stats_out"), pmt.to_pmt(stats["display"]))

              self._window_started = now
              self._window_decode = 0
              self._window_errors = 0

          def _assess_quality(self, bits, format_id):
              errors = []
              score = 1.0

              expected_len = self.FRAME_WORDS * self.PAYLOAD_BITS_PER_WORD
              if len(bits) != expected_len:
                  errors.append({"code": "framing.length_mismatch", "message": f"expected {expected_len} bits got {len(bits)}"})
                  score -= 0.6

              if format_id not in (0, 1, 2, 3):
                  errors.append({"code": "decode.invalid_format_id", "message": f"invalid format_id={format_id}"})
                  score -= 0.6

              ones = sum(int(b) for b in bits)
              ratio = ones / len(bits) if bits else 0.0
              if ratio < 0.10 or ratio > 0.90:
                  errors.append({"code": "signal.bit_balance_extreme", "message": f"ones_ratio={ratio:.3f}"})
                  score -= 0.25

              score = max(0.0, min(1.0, score))
              confidence = "high" if score >= 0.85 else ("medium" if score >= 0.60 else "low")

              return {
                  "score": round(score, 3),
                  "confidence": confidence,
                  "ones_ratio": round(ratio, 3),
              }, errors

          def _decode_message_bits(self, bits):
              msg_int = np.uint32(0)
              for b in bits:
                  msg_int = (msg_int << 1) | np.uint32(b)

              sensor_id = (msg_int >> 0) & 0x3F
              sensor_id |= ((msg_int >> 8) & 0x3F) << 6
              sensor_id |= ((msg_int >> 16) & 0x01) << 12

              format_id = int((msg_int >> 6) & 0x03)
              is_binary = format_id == 2

              data_val = (msg_int >> 17) & 0x1F
              data_val |= ((msg_int >> 24) & 0x3F) << 5

              raw_bits = ''.join(str(int(b)) for b in bits)
              raw_hex = f"{int(msg_int):08X}"

              quality, errors = self._assess_quality(bits, format_id)
              status = "ok" if not errors else ("warn" if quality["score"] >= 0.60 else "error")

              summary = f"{int(sensor_id):04d}, {int(data_val):06d}"

              return {
                  "schema": "alert.decode.v1",
                  "ts": self._now_iso(),
                  "status": status,
                  "quality": quality,
                  "errors": errors,
                  "frame": {
                      "bits_per_word": self.bits_per_word,
                      "word_count": self.FRAME_WORDS,
                      "payload_bits": raw_bits,
                      "payload_hex": raw_hex,
                  },
                  "decode": {
                      "sensor_id": int(sensor_id),
                      "format_id": format_id,
                      "is_binary": bool(is_binary),
                      "data_val": int(data_val),
                  },
                  "summary": summary,
                  "display": summary,
              }

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              consumed = 0
              produced = 0
              out_capacity = len(out0)

              for float_sample in in0:
                  logical_bit = 1 if float_sample > 0.5 else 0
                  consumed += 1
                  self._samples_since_frame += 1

                  if self.state == "HUNTING_S":
                      if logical_bit == 1:
                          self.state = "COLLECTING_WORD"
                          self.bit_buffer = [logical_bit]

                      if self._samples_since_frame >= self.HUNT_TIMEOUT_SAMPLES and not self._hunt_timeout_raised:
                          self._publish_decode_error(
                              "timing.hunt_timeout",
                              "no complete frame detected within hunt timeout",
                              details={
                                  "samples_since_frame": int(self._samples_since_frame),
                                  "timeout_samples": int(self.HUNT_TIMEOUT_SAMPLES),
                              },
                          )
                          self.error_total += 1
                          self._window_errors += 1
                          self._hunt_timeout_raised = True
                      continue

                  if self.state == "COLLECTING_WORD":
                      self.bit_buffer.append(logical_bit)

                      if len(self.bit_buffer) < self.bits_per_word:
                          continue

                      self.message_bits.extend(self.bit_buffer[1:9])
                      self.word_count += 1

                      if self.word_count == self.FRAME_WORDS:
                          event = self._decode_message_bits(self.message_bits)
                          self._publish_event(event)
                          self.frames_total += 1
                          self._samples_since_frame = 0
                          self._hunt_timeout_raised = False

                          if event.get("errors"):
                              self.error_total += len(event.get("errors"))
                              self._window_errors += len(event.get("errors"))

                          if produced < out_capacity:
                              out0[produced] = float(event["decode"]["data_val"])
                              produced += 1
                              self.frames_decoded += 1
                              self._window_decode += 1
                          else:
                              self.frames_dropped_output_full += 1
                              self.error_total += 1
                              self._window_errors += 1
                              self._publish_decode_error(
                                  "pipeline.output_overflow",
                                  "output buffer full; decode output sample dropped",
                                  details={"out_capacity": int(out_capacity)},
                              )

                          self._reset_frame_collection()
                      else:
                          self._reset_word_collection()

                      self._publish_stats_if_due()

              self._publish_stats_if_due()
              self.consume(0, consumed)
              return produced
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import json
      import time
      from gnuradio import gr
      import pmt


      class mqtt_event_publisher(gr.basic_block):
          """
          Publish ALERT decode/status events to MQTT.

          Topic layout (prefix default: alert):
            <prefix>/rx/decoded
            <prefix>/rx/raw
            <prefix>/rx/status
            <prefix>/rx/metrics
          """

          def __init__(self, broker_host='127.0.0.1', broker_port=1883, username='', password='', topic_prefix='alert'):
              gr.basic_block.__init__(self, name='ALERT MQTT Publisher', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self.broker_host = broker_host
              self.broker_port = int(broker_port)
              self.username = username
              self.password = password
              self.topic_prefix = topic_prefix.strip('/') or 'alert'

              self._client = None
              self._connected = False
              self._published = 0
              self._dropped = 0
              self._last_metrics = 0.0

              self._setup_client()

          def _setup_client(self):
              try:
                  import paho.mqtt.client as mqtt
              except Exception as exc:
                  self.logger.error(f'MQTT disabled (paho-mqtt unavailable): {exc}')
                  return

              self._client = mqtt.Client(client_id='alert1v3-rx', clean_session=True)
              if self.username:
                  self._client.username_pw_set(self.username, self.password)

              self._client.on_connect = self._on_connect
              self._client.on_disconnect = self._on_disconnect

              try:
                  self._client.connect_async(self.broker_host, self.broker_port, keepalive=30)
                  self._client.loop_start()
              except Exception as exc:
                  self.logger.error(f'MQTT connect failed: {exc}')
                  self._client = None

          def _on_connect(self, _client, _userdata, _flags, rc):
              self._connected = (rc == 0)
              if rc != 0:
                  self.logger.error(f'MQTT connect returned rc={rc}')

          def _on_disconnect(self, _client, _userdata, _rc):
              self._connected = False

          def _publish_json(self, topic_suffix, payload):
              if not self._client or not self._connected:
                  self._dropped += 1
                  return

              topic = f'{self.topic_prefix}/{topic_suffix}'
              try:
                  self._client.publish(topic, json.dumps(payload, default=str), qos=0, retain=False)
                  self._published += 1
              except Exception as exc:
                  self._dropped += 1
                  self.logger.error(f'MQTT publish failed ({topic}): {exc}')

          def _publish_metrics(self, event):
              now = time.time()
              if now - self._last_metrics < 5.0:
                  return
              self._last_metrics = now

              metrics = {
                  'schema': 'alert.mqtt.metrics.v1',
                  'ts': event.get('ts', ''),
                  'status': 'ok' if self._connected else 'disconnected',
                  'broker': f'{self.broker_host}:{self.broker_port}',
                  'published': self._published,
                  'dropped': self._dropped,
              }
              self._publish_json('rx/metrics', metrics)

          def handle_msg(self, msg):
              try:
                  event = pmt.to_python(msg)
              except Exception:
                  event = str(msg)

              if not isinstance(event, dict):
                  event = {
                      'schema': 'alert.decode.v1',
                      'ts': '',
                      'status': 'raw',
                      'summary': str(event),
                      'decode': {},
                      'frame': {},
                  }

              decode = event.get('decode', {}) if isinstance(event.get('decode'), dict) else {}
              frame = event.get('frame', {}) if isinstance(event.get('frame'), dict) else {}

              self._publish_json('rx/decoded', event)
              self._publish_json('rx/raw', {
                  'schema': event.get('schema', 'alert.decode.v1'),
                  'ts': event.get('ts', ''),
                  'status': event.get('status', 'unknown'),
                  'frame': frame,
              })
              self._publish_json('rx/status', {
                  'schema': event.get('schema', 'alert.decode.v1'),
                  'ts': event.get('ts', ''),
                  'status': event.get('status', 'unknown'),
                  'summary': event.get('summary', ''),
                  'sensor_id': decode.get('sensor_id'),
                  'format_id': decode.get('format_id'),
              })
              self._publish_metrics(event)

          def stop(self):
              if self._client:
                  try:
                      self._client.loop_stop()
                      self._client.disconnect()
                  except Exception:
                      pass
              return True
    broker_host: mqtt_broker_host
    broker_port: mqtt_broker_port
    password: mqtt_password
    topic_prefix: mqtt_topic_prefix
    username: mqtt_username
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabwid0@0:4,0,1,4
    is_pair: 'False'
    label: Decoder counters
    type: string
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5*300
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabwid0@0:3,0,1,4
    is_pair: 'False'
    label: Latest decode
    type: string
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    alpha1: '1'
    axislabels: 'False'
    color1: '1'
    grid: 'True'
    gui_hint: tabwid0@2:1,0,3,3
    ncols: '250'
    nrows: '30'
    samp_rate: samp_rate
    type: float
    x_end_value: '250'
    y_end_value: '30'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '2.0'
    autoscale: 'True'
    axislabels: 'False'
    color1: green
    entags: 'False'
    grid: 'True'
    gui_hint: tabwid0@2:0,0,1,1
    label1: '1'
    legend: 'False'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    style1: '4'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '2.0'
    autoscale: 'True'
    axislabels: 'False'
    color1: red
    entags: 'False'
    grid: 'True'
    gui_hint: tabwid0@2:0,1,1,1
    label1: '1'
    legend: 'False'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    axislabels: 'False'
    entags: 'False'
    grid: 'True'
    gui_hint: tabwid0@1:3,0,1,1
    legend: 'False'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: 100e3
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabwid0@1:1,0,2,2
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: 100e3
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabwid0@1:1,2,2,2
    legend: 'False'
    name: ''
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: center_freq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tabwid0
  id: qtgui_tab_widget
  parameters:
    label0: Operator
    label1: Signal
    label2: Diagnostics
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: raw_rf
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf_1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: raw_rf
  states: {}

connections:
- [analog_agc_xx_0, '0', low_pass_filter_1, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_wfm_rcv_0, '0', analog_agc_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_null_source_0, '0', audio_sink_1, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [epy_block_1, '0', blocks_null_sink_2, '0']
- [epy_block_1, debug_out, epy_block_0, msg_in]
- [epy_block_1, debug_out, qtgui_edit_box_msg_0, val]
- [epy_block_1, stats_out, qtgui_edit_box_msg_1, val]
- [epy_block_1, debug_out, epy_block_2, msg_in]
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_1_1, '0']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
