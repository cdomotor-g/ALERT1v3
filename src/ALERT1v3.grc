options:
  parameters:
    author: CD
    copyright: BoM
    description: 'Legacy ALERT '
    generate_options: qt_gui
    id: ALERT1v3
    output_language: python
    title: ALERT1v3
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 173.9e6
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabwid0@0:2,0,1,4
    start: 100e6
    step: 25e3
    stop: 200e6
    value: 173.9e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '250'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: rfGain
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabwid0@0:0,0,1,4
    start: '-100'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: rf_squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: tabwid0@0:1,0,1,4
    min_len: '1'
    start: '-50'
    step: '1'
    stop: '0'
    value: '-33'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: fsk_deviation_hz/2
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '0'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/decimation)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: rf_squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate_audio
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.04
    max_dev: '1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: demod_rate/300
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import json
      from gnuradio import gr
      import pmt
      import datetime
      import os
      import csv


      class blk(gr.basic_block):
          """
          ALERT decode logger.

          Accepts structured PMT messages on 'msg_in' and writes:
            - CSV summary rows
            - JSONL full events

          File layout:
            <base_path>/<YYYY-MM-DD>/
              rx_data_<HHMMSS>.csv
              rx_events_<HHMMSS>.jsonl
          """

          def __init__(self, base_path='/home/pi/rf_logs'):
              gr.basic_block.__init__(self, name='ALERT Event Logger', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

              self.base_path = base_path
              self.current_date = ''
              self.csv_file = None
              self.jsonl_file = None
              self.csv_writer = None

          def _open_session_files(self):
              now = datetime.datetime.now()
              date_str = now.strftime('%Y-%m-%d')
              session_str = now.strftime('%H%M%S')

              target_dir = os.path.join(self.base_path, date_str)
              os.makedirs(target_dir, exist_ok=True)

              csv_path = os.path.join(target_dir, f'rx_data_{session_str}.csv')
              jsonl_path = os.path.join(target_dir, f'rx_events_{session_str}.jsonl')

              self.csv_file = open(csv_path, 'a', newline='')
              self.jsonl_file = open(jsonl_path, 'a')
              self.csv_writer = csv.writer(self.csv_file)
              self.csv_writer.writerow([
                  'timestamp', 'status', 'sensor_id', 'format_id', 'is_binary', 'data_val', 'payload_hex', 'summary'
              ])
              self.current_date = date_str

          def _ensure_files(self):
              date_str = datetime.datetime.now().strftime('%Y-%m-%d')
              if self.csv_file is None or self.jsonl_file is None or date_str != self.current_date:
                  self._close_files()
                  self._open_session_files()

          def _close_files(self):
              if self.csv_file:
                  try:
                      self.csv_file.flush()
                      self.csv_file.close()
                  except Exception:
                      pass
              if self.jsonl_file:
                  try:
                      self.jsonl_file.flush()
                      self.jsonl_file.close()
                  except Exception:
                      pass
              self.csv_file = None
              self.jsonl_file = None
              self.csv_writer = None

          def handle_msg(self, msg):
              try:
                  self._ensure_files()

                  event = pmt.to_python(msg)
                  if not isinstance(event, dict):
                      event = {
                          'schema': 'alert.decode.v1',
                          'ts': datetime.datetime.utcnow().isoformat() + 'Z',
                          'status': 'raw',
                          'summary': str(event),
                      }

                  decode = event.get('decode', {}) if isinstance(event.get('decode', {}), dict) else {}
                  frame = event.get('frame', {}) if isinstance(event.get('frame', {}), dict) else {}

                  row = [
                      event.get('ts', datetime.datetime.utcnow().isoformat() + 'Z'),
                      event.get('status', 'unknown'),
                      decode.get('sensor_id', ''),
                      decode.get('format_id', ''),
                      decode.get('is_binary', ''),
                      decode.get('data_val', ''),
                      frame.get('payload_hex', ''),
                      event.get('summary', ''),
                  ]

                  self.csv_writer.writerow(row)
                  self.csv_file.flush()

                  self.jsonl_file.write(json.dumps(event, default=str) + '\n')
                  self.jsonl_file.flush()

              except Exception as e:
                  self.logger.error(f'Logging error: {e}')

          def stop(self):
              self._close_files()
              return True
    base_path: '''/home/cdomotor/rf_log'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime


      class alert_protocol_decoder(gr.basic_block):
          """
          ALERT protocol decoder.

          Input:
            - float stream containing symbol decisions / soft-ish values

          Output stream (single float, kept for GRC compatibility):
            - decoded data_val as float

          Message output:
            - debug_out (PMT dict with structured decode payload)
          """

          FRAME_WORDS = 4

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="ALERT Protocol Decoder",
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )

              self.message_port_register_out(pmt.intern("debug_out"))

              self.state = "HUNTING_S"
              self.bit_buffer = []
              self.message_bits = []
              self.bits_per_word = 10
              self.word_count = 0

              # Runtime counters to help verify behavior during long runs.
              self.frames_decoded = 0
              self.frames_dropped_output_full = 0

          def _publish_event(self, event_dict):
              try:
                  msg = pmt.to_pmt(event_dict)
              except Exception:
                  # Fallback to string if PMT conversion fails for any reason.
                  msg = pmt.intern(str(event_dict))
              self.message_port_pub(pmt.intern("debug_out"), msg)

          def _reset_frame_collection(self):
              self.word_count = 0
              self.message_bits = []
              self.state = "HUNTING_S"
              self.bit_buffer = []

          def _decode_message_bits(self, bits):
              """Decode 32 collected bits into fields using current legacy mapping."""
              msg_int = np.uint32(0)
              for b in bits:
                  msg_int = (msg_int << 1) | np.uint32(b)

              sensor_id = (msg_int >> 0) & 0x3F
              sensor_id |= ((msg_int >> 8) & 0x3F) << 6
              sensor_id |= ((msg_int >> 16) & 0x01) << 12

              format_id = (msg_int >> 6) & 0x03
              is_binary = format_id == 2

              data_val = (msg_int >> 17) & 0x1F
              data_val |= ((msg_int >> 24) & 0x3F) << 5

              raw_bits = ''.join(str(int(b)) for b in bits)
              raw_hex = f"{int(msg_int):08X}"
              summary = f"{int(sensor_id):04d}, {int(data_val):06d}"

              return {
                  "schema": "alert.decode.v1",
                  "ts": datetime.datetime.utcnow().isoformat() + "Z",
                  "status": "ok",
                  "frame": {
                      "bits_per_word": self.bits_per_word,
                      "word_count": self.FRAME_WORDS,
                      "payload_bits": raw_bits,
                      "payload_hex": raw_hex,
                  },
                  "decode": {
                      "sensor_id": int(sensor_id),
                      "format_id": int(format_id),
                      "is_binary": bool(is_binary),
                      "data_val": int(data_val),
                  },
                  "summary": summary,
                  "display": summary,
              }

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              consumed = 0
              produced = 0
              out_capacity = len(out0)

              for float_sample in in0:
                  logical_bit = 1 if float_sample > 0.5 else 0
                  consumed += 1

                  if self.state == "HUNTING_S":
                      if logical_bit == 1:
                          self.state = "COLLECTING_WORD"
                          self.bit_buffer = [logical_bit]
                      continue

                  if self.state == "COLLECTING_WORD":
                      self.bit_buffer.append(logical_bit)

                      if len(self.bit_buffer) < self.bits_per_word:
                          continue

                      # Keep legacy behavior: consume payload bits [1:9] from each 10-bit word.
                      self.message_bits.extend(self.bit_buffer[1:9])
                      self.word_count += 1

                      if self.word_count == self.FRAME_WORDS:
                          event = self._decode_message_bits(self.message_bits)
                          self._publish_event(event)

                          if produced < out_capacity:
                              out0[produced] = float(event["decode"]["data_val"])
                              produced += 1
                              self.frames_decoded += 1
                          else:
                              # Keep decoding/logging alive even when scheduler gives no output room.
                              self.frames_dropped_output_full += 1

                      self._reset_frame_collection()

              self.consume(0, consumed)
              return produced
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5*300
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabwid0@1:6,0,1,1
    is_pair: 'False'
    type: string
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    alpha1: '1'
    axislabels: 'False'
    color1: '1'
    grid: 'True'
    gui_hint: tabwid0@1:3,1,4,3
    ncols: '250'
    nrows: '30'
    samp_rate: samp_rate
    type: float
    x_end_value: '250'
    y_end_value: '30'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '2.0'
    autoscale: 'True'
    axislabels: 'False'
    color1: green
    entags: 'False'
    grid: 'True'
    gui_hint: tabwid0@1:4,0,1,1
    label1: '1'
    legend: 'False'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    style1: '4'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '2.0'
    autoscale: 'True'
    axislabels: 'False'
    color1: red
    entags: 'False'
    grid: 'True'
    gui_hint: tabwid0@1:5,0,1,1
    label1: '1'
    legend: 'False'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    axislabels: 'False'
    entags: 'False'
    grid: 'True'
    gui_hint: tabwid0@1:3,0,1,1
    legend: 'False'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: 100e3
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabwid0@1:1,0,2,2
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: 100e3
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabwid0@1:1,2,2,2
    legend: 'False'
    name: ''
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: center_freq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tabwid0
  id: qtgui_tab_widget
  parameters:
    label0: config
    label1: run
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: raw_rf
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf_1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: raw_rf
  states: {}

connections:
- [analog_agc_xx_0, '0', low_pass_filter_1, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_wfm_rcv_0, '0', analog_agc_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_null_source_0, '0', audio_sink_1, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [epy_block_1, '0', blocks_null_sink_2, '0']
- [epy_block_1, debug_out, epy_block_0, msg_in]
- [epy_block_1, debug_out, qtgui_edit_box_msg_0, val]
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_1_1, '0']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
