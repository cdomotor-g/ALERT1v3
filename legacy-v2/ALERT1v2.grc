options:
  parameters:
    author: CD
    copyright: BoM
    description: 'Legacy ALERT '
    generate_options: bokeh_gui
    id: ALERT1v1
    output_language: python
    title: ALERT1v2
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 173.9e6
  states: {}
- name: col2
  id: variable
  parameters:
    value: 0,0,4,1
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '250'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: rfGain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: row1
  id: variable
  parameters:
    value: 0,1,1,2
  states: {}
- name: row2
  id: variable
  parameters:
    value: 1,1,1,2
  states: {}
- name: row3
  id: variable
  parameters:
    value: 2,1,1,2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: fsk_deviation_hz/2
  states: {}
- name: variable_bokehgui_button_0
  id: variable_bokehgui_button
  parameters:
    block_id: my_block_0
    function_args: ''
    function_name: get_number
    label: ''
    type: bool
    value: 'True'
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '0'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/decimation)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-33'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate_audio
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: bokehgui_time_sink_x_0
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'False'
    grid: 'True'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    name: '""'
    nconnections: '1'
    placement: row2
    size: '512'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: float
    update_time: '100'
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'True'
    xunit: ''
    ylabel: Amplitude
    ylog: 'False'
    ymax: '1'
    ymin: '-1'
    yunit: ''
  states: {}
- name: bokehgui_time_sink_x_1
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    name: '""'
    nconnections: '1'
    placement: row3
    size: '512'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: float
    update_time: '100'
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'False'
    xunit: ''
    ylabel: Amplitude
    ylog: 'False'
    ymax: '1'
    ymin: '-1'
    yunit: ''
  states: {}
- name: bokehgui_time_sink_x_2
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    name: '""'
    nconnections: '1'
    placement: row1
    size: '512'
    srate: '48000'
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: float
    update_time: '100'
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'False'
    xunit: ''
    ylabel: Amplitude
    ylog: 'False'
    ymax: '5'
    ymin: '-5'
    yunit: ''
  states: {}
- name: bokehgui_waterfall_sink_x_0
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: 120e3
    color: Inferno
    fc: '0'
    fftsize: '128'
    grid: 'True'
    int_max: '0'
    int_min: '-70'
    label: ''
    legend: 'True'
    name: '""'
    placement: 0,0,1,2
    type: complex
    update_time: '100'
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {state: disabled}
- name: bokehgui_waterfall_sink_x_1
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: 80e3
    color: Inferno
    fc: '0'
    fftsize: '128'
    grid: 'False'
    int_max: '8'
    int_min: '-120'
    label: ''
    legend: 'True'
    name: '""'
    placement: col2
    type: float
    update_time: '100'
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.04
    max_dev: '1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: demod_rate/300
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime
      import os
      import csv

      class blk(gr.basic_block):
          def __init__(self, base_path='/home/pi/rf_logs'):
              gr.basic_block.__init__(self, name='CSV Daily Logger', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.base_path = base_path
              self.current_file = None
              self.current_date = ""

          def get_filepath(self):
              now = datetime.datetime.now()
              date_str = now.strftime("%Y-%m-%d")
              # Create subdirectories by date
              target_dir = os.path.join(self.base_path, date_str)
              if not os.path.exists(target_dir):
                  os.makedirs(target_dir)
              
              # New file per session or per day
              filename = f"rx_data_{now.strftime('%H%M%S')}.csv"
              return os.path.join(target_dir, filename), date_str

          def handle_msg(self, msg):
              now = datetime.datetime.now()
              date_str = now.strftime("%Y-%m-%d")
              
              # Daily rotation: Check if the date has changed since the last message
              if date_str != self.current_date:
                  path, self.current_date = self.get_filepath()
                  self.current_file = open(path, 'a', newline='')
                  writer = csv.writer(self.current_file)
                  writer.writerow(['timestamp', 'data_payload']) # Add your custom headers here
                  
              # Extract data from PMT message (adjust pmt.to_python based on your decoder output)
              try:
                  data_content = pmt.to_python(msg) 
                  writer = csv.writer(self.current_file)
                  writer.writerow([now.isoformat(), data_content])
                  self.current_file.flush() # Ensure data is written to disk
              except Exception as e:
                  self.logger.error(f"Logging error: {e}")
    base_path: '''/home/cdomotor/rf_log'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class alert_protocol_decoder(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="ALERT Protocol Decoder",
                  in_sig=[np.float32],
                  # Output 0: Sensor ID, Output 1: Data Val, Output 2: Is Binary
                  out_sig=[np.float32, np.float32, np.float32])
              
              self.message_port_register_out(pmt.intern("msg_out"))
              
              self.state = "HUNTING_S"
              self.bit_buffer = []
              self.message_bits = []
              self.bits_per_word = 10 
              self.word_count = 0

          def debug_log(self, this_text):
              msg = pmt.intern(str(this_text) + "\n")
              self.message_port_pub(pmt.intern("msg_out"), msg)
              print(f"RX: {this_text}")

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              # Map the three output streams
              out_id = output_items[0]
              out_val = output_items[1]
              out_bin = output_items[2]
              
              consumed = 0
              produced = 0
              
              for float_sample in in0:
                  logical_bit = 1 if float_sample > 0.5 else 0 
                  consumed += 1

                  if self.state == "HUNTING_S":
                      if logical_bit == 1:
                          self.state = "COLLECTING_WORD"
                          self.bit_buffer = [logical_bit]
                  
                  elif self.state == "COLLECTING_WORD":
                      self.bit_buffer.append(logical_bit)
                      
                      if len(self.bit_buffer) == self.bits_per_word:
                          self.message_bits.extend(self.bit_buffer[1:9])
                          self.word_count += 1
                          
                          if self.word_count == 4:
                              # 1. Reassemble to 32-bit integer
                              msg_int = np.uint32(0)
                              for b in self.message_bits:
                                  msg_int = (msg_int << 1) | np.uint32(b)
                              
                              # 2. Extract Fields (Logic from your commented block)
                              sensor_id = (msg_int >> 0) & 0x3F
                              sensor_id |= ((msg_int >> 8) & 0x3F) << 6
                              sensor_id |= ((msg_int >> 16) & 0x01) << 12

                              format_id = (msg_int >> 6) & 0x03
                              is_binary = 1.0 if format_id == 2 else 0.0
                              
                              data_val = (msg_int >> 17) & 0x1F
                              data_val |= ((msg_int >> 24) & 0x3F) << 5

                              # 3. Assign to Output Streams
                              out_id[produced] = float(sensor_id)
                              out_val[produced] = float(data_val)
                              out_bin[produced] = float(is_binary)
                              
                              #self.debug_log(f"ID={sensor_id:04d}, VAL={data_val:06d}, BIN={is_binary}, BITS={len(self.message_bits)}")
                              self.debug_log(f"{sensor_id:04d}, {data_val:06d}")
                              
                              produced += 1
                              self.word_count = 0 
                              self.message_bits = []
                          
                          self.state = "HUNTING_S" 
                          self.bit_buffer = []

              self.consume(0, consumed)
              return produced
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5*300
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: center_freq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: raw_rf
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf_1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: raw_rf
  states: {}

connections:
- [analog_agc_xx_0, '0', low_pass_filter_1, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_wfm_rcv_0, '0', analog_agc_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', bokehgui_time_sink_x_2, '0']
- [blocks_null_source_0, '0', audio_sink_1, '0']
- [digital_symbol_sync_xx_0, '0', bokehgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_1, '0']
- [epy_block_1, '0', blocks_null_sink_0, '0']
- [epy_block_1, '1', blocks_null_sink_0, '1']
- [epy_block_1, '2', blocks_null_sink_0, '2']
- [epy_block_1, msg_out, epy_block_0, msg_in]
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', bokehgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', bokehgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', bokehgui_waterfall_sink_x_1, '0']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
