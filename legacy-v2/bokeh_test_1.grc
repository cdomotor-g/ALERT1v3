options:
  parameters:
    generate_options: bokeh_gui
    id: bokeh_test_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 173.9e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '250'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: rfGain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: fsk_deviation_hz/2
  states: {}
- name: bokehgui_waterfall_sink_x_0
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: 100e3
    color: Inferno
    fc: '0'
    fftsize: '256'
    grid: 'False'
    int_max: '10'
    int_min: '-140'
    label: ''
    legend: 'True'
    name: '""'
    placement: 1,0,2,2
    type: complex
    update_time: '100'
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: center_freq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [low_pass_filter_0, '0', bokehgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
